# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp\inc;..\..\User\bsp;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h Motor_control.c Motor_data_process.c delay.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c stm32f4xx_assert.c bsp_can.c
    ../../User/bsp/src/: bsp_led.c bsp_key.c bsp_uart_fifo.c bsp_tim_pwm.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_usart.c stm32f4xx_exti.c
  group CMSIS
    ../../User/bsp/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
software components: CMSIS:CORE 5.6.0

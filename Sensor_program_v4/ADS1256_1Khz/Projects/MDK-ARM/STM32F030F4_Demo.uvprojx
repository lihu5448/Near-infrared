# Keil uVision project STM32F030F4_Demo.uvprojx, settings and files
target STM32F030F4 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BaiZong_V1_1_0 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\..\BSP;..\..\Libraries;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Source;..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\Projects;..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./../: system_stm32f0xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group BSP
    ../../BSP/: USART1.c USART1.h my_fifo.c my_fifo.h TIM.c TIM.h my_flash.c my_flash.h ADS1255.c ADS1255.h
  group STM32F0xx_StdPeriph_Driver
    ../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_misc.c
  group User
    ./../: main.c stm32f0xx_it.c
software components: CMSIS:CORE 5.0.1
